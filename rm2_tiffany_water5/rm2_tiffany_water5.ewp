# IAR project rm2_tiffany_water5.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG210F32 SiliconLaboratories EFM32TG210F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: EFM32TG210F32
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include; inc; ..\rm2_libs\Device\SiliconLabs\EFM32TG\Include; ..\rm2_libs\emlib\inc; ..\rm2_libs\libtd1202\inc; ..\rm2_libs\libtdrf\inc; ..\rm2_libs\UNB; ..\rm2_libs\RM2_HAL; ..\rm2_libs\CMSIS\Include; ..\rm2_libs\emdrv\gpiointerrupt\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rm2_tiffany_water5.hex
  ILINK.IlinkOutputFile: rm2_tiffany_water.out
  ILINK.IlinkAdditionalLibs: ..\rm2_libs\libtdrf\libtdrf.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group inc
    inc/: defines.h rm2_settings.h water5.h
    ../rm2_libs/RM2_HAL/: rm2_hal.h
  group libs/Device
    ../rm2_libs/Device/SiliconLabs/EFM32TG/Source/IAR/: startup_efm32tg.c
    ../rm2_libs/Device/SiliconLabs/EFM32TG/Source/: system_efm32tg.c
  group libs/emlib
    ../rm2_libs/emlib/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_idac.c em_int.c em_lcd.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group libs/gpiointerrupt
    ../rm2_libs/emdrv/gpiointerrupt/src/: gpiointerrupt.c
  group libs/libtd1202
    ../rm2_libs/libtd1202/src/: at_parse.c td_cmu.c td_flash.c td_gpio.c td_main.c td_measure.c td_printf.c td_rtc.c td_timer.c td_uart.c td_utils.c
  group libs/RM2_HAL
    ../rm2_libs/RM2_HAL/: rm2_hal.c
  group libs/UNB
    ../rm2_libs/UNB/: UNB.c UNB.h XTEA.c XTEA.h
  group src
    src/: main.c water5.c
