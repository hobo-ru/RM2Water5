<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\rm2_tiffany_water5\rm2_tiffany_water5.ewp</path>
  </project>
  <batchBuild/>
</workspace>


